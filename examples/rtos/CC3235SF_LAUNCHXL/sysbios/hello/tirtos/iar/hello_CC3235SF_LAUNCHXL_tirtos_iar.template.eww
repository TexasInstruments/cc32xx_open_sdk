<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/hello_CC3235SF_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>