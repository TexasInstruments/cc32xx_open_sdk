# IAR project connection_manager_CC3235SF_LAUNCHXL_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: connection_manager_CC3235SF_LAUNCHXL_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
