<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/power_measurement_CC3220SF_LAUNCHXL_freertos_iar.ewp</path>
    </project>
    <project>
        <path>$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/kernel/freertos/builds/cc32xx/release/iar/freertos_builds_cc32xx_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>